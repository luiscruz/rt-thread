# Keil uVision project project.uvproj, settings and files
target RT-Thread STM32 (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .;..\..\components\finsh;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;Libraries.2011\CMSIS\CM3\CoreSupport;Libraries.2011\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;Libraries.2011\STM32F2xx_StdPeriph_Driver\inc;applications;drivers;..\..\components\rtgui\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c startup.c
    ./: seps525.c key.c cpal_usercallback.c
  group Drivers
    Drivers/: 24LCxx.c FM25Lx.c board.c i2c.c rtc.c serial.c stm32f2xx_it.c usart.c
    ./Drivers/: bmp085.c
  group STM32_StdPeriph.2011
    Libraries.2011/CMSIS/CM3/CoreSupport/: core_cm3.c
    Libraries.2011/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
    Libraries.2011/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    Libraries.2011/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group STM32_StdPeriph
    Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
    Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3.2011
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group RTGUI
    ../../components/rtgui/common/: asc12font.c asc16font.c blit.c color.c dc.c dc_buffer.c dc_client.c dc_hw.c filerw.c font.c font_bmp.c font_freetype.c font_hz_bmp.c font_hz_file.c framebuffer_driver.c hz12font.c hz16font.c image.c image_bmp.c image_container.c image_hdc.c image_jpg.c image_png.c image_xpm.c pixel_driver.c region.c rtgui_app.c rtgui_mv_model.c rtgui_object.c rtgui_system.c rtgui_theme.c rtgui_xml.c
    ../../components/rtgui/server/: driver.c mouse.c server.c topwin.c
    ../../components/rtgui/widgets/: box.c button.c checkbox.c combobox.c container.c edit.c filelist_view.c groupbox.c iconbox.c label.c list_view.c listbox.c listctrl.c menu.c mv_view.c notebook.c panel.c plot.c plot_curve.c progressbar.c radiobox.c scrollbar.c slider.c staticline.c textbox.c textview.c title.c widget.c window.c
  group gui_demo
    ../../examples/gui/: demo_application.c demo_fnview.c demo_listview.c demo_listview_icon.c demo_panel.c demo_panel_single.c demo_plot.c demo_simple_workbench.c demo_view.c demo_view_animation.c demo_view_benchmark.c demo_view_bmp.c demo_view_box.c demo_view_buffer_animation.c demo_view_button.c demo_view_checkbox.c demo_view_combobox.c demo_view_dc.c demo_view_dc_buffer.c demo_view_edit.c demo_view_image.c demo_view_instrument_panel.c demo_view_label.c demo_view_listbox.c demo_view_listctrl.c demo_view_menu.c demo_view_module.c demo_view_mywidget.c demo_view_notebook.c demo_view_progressbar.c demo_view_radiobox.c demo_view_scrollbar.c demo_view_slider.c demo_view_textbox.c demo_view_ttf.c demo_view_window.c demo_xml.c mywidget.c
  group CPAL1.1.0
    ./Drivers/STM32_EVAL_CPAL/: stm32_eval_i2c_lsm303dlx_cpal.c stm322xg_eval_bmp085_cpal.c
    ./Libraries/STM32_CPAL_Driver/devices/stm32f2xx/: cpal_i2c_hal_stm32f2xx.c
    ./Libraries/STM32_CPAL_Driver/src/: cpal_hal.c cpal_i2c.c cpal_usercallback_template.c
